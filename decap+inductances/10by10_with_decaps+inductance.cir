* This file is generated using a Python script.
* DO NOT EDIT THIS FILE MANUALLY. Your changes will be lost.
.title 10x10 grid of 1ohm (realistic) resistors + decaps
*
.tran 1ps 4ns
.measure tran yavg AVG i(Vin) from=0ns to=2ns
*
* resistance segment model:
.subckt Rseg 1 3
R1 1 2 0.583
L1 2 3 0.003n
C1 1 0 0.25e-12
C2 3 0 0.25e-12
.ends
X1 1 2 Rseg
X2 2 3 Rseg
X3 3 4 Rseg
X4 4 5 Rseg
X5 5 6 Rseg
X6 6 7 Rseg
X7 7 8 Rseg
X8 8 9 Rseg
X9 9 10 Rseg
X10 10 11 Rseg
X11 12 13 Rseg
X12 13 14 Rseg
X13 14 15 Rseg
X14 15 16 Rseg
X15 16 17 Rseg
X16 17 18 Rseg
X17 18 19 Rseg
X18 19 20 Rseg
X19 20 21 Rseg
X20 21 22 Rseg
X21 23 24 Rseg
X22 24 25 Rseg
X23 25 26 Rseg
X24 26 27 Rseg
X25 27 28 Rseg
X26 28 29 Rseg
X27 29 30 Rseg
X28 30 31 Rseg
X29 31 32 Rseg
X30 32 33 Rseg
X31 34 35 Rseg
X32 35 36 Rseg
X33 36 37 Rseg
X34 37 38 Rseg
X35 38 39 Rseg
X36 39 40 Rseg
X37 40 41 Rseg
X38 41 42 Rseg
X39 42 43 Rseg
X40 43 44 Rseg
X41 45 46 Rseg
X42 46 47 Rseg
X43 47 48 Rseg
X44 48 49 Rseg
X45 49 50 Rseg
X46 50 51 Rseg
X47 51 52 Rseg
X48 52 53 Rseg
X49 53 54 Rseg
X50 54 55 Rseg
X51 56 57 Rseg
X52 57 58 Rseg
X53 58 59 Rseg
X54 59 60 Rseg
X55 60 61 Rseg
X56 61 62 Rseg
X57 62 63 Rseg
X58 63 64 Rseg
X59 64 65 Rseg
X60 65 66 Rseg
X61 67 68 Rseg
X62 68 69 Rseg
X63 69 70 Rseg
X64 70 71 Rseg
X65 71 72 Rseg
X66 72 73 Rseg
X67 73 74 Rseg
X68 74 75 Rseg
X69 75 76 Rseg
X70 76 77 Rseg
X71 78 79 Rseg
X72 79 80 Rseg
X73 80 81 Rseg
X74 81 82 Rseg
X75 82 83 Rseg
X76 83 84 Rseg
X77 84 85 Rseg
X78 85 86 Rseg
X79 86 87 Rseg
X80 87 88 Rseg
X81 89 90 Rseg
X82 90 91 Rseg
X83 91 92 Rseg
X84 92 93 Rseg
X85 93 94 Rseg
X86 94 95 Rseg
X87 95 96 Rseg
X88 96 97 Rseg
X89 97 98 Rseg
X90 98 99 Rseg
X91 100 101 Rseg
X92 101 102 Rseg
X93 102 103 Rseg
X94 103 104 Rseg
X95 104 105 Rseg
X96 105 106 Rseg
X97 106 107 Rseg
X98 107 108 Rseg
X99 108 109 Rseg
X100 109 110 Rseg
X101 111 112 Rseg
X102 112 113 Rseg
X103 113 114 Rseg
X104 114 115 Rseg
X105 115 116 Rseg
X106 116 117 Rseg
X107 117 118 Rseg
X108 118 119 Rseg
X109 119 120 Rseg
X110 120 121 Rseg
X111 1 12 Rseg
X112 2 13 Rseg
X113 3 14 Rseg
X114 4 15 Rseg
X115 5 16 Rseg
X116 6 17 Rseg
X117 7 18 Rseg
X118 8 19 Rseg
X119 9 20 Rseg
X120 10 21 Rseg
X121 11 22 Rseg
X122 12 23 Rseg
X123 13 24 Rseg
X124 14 25 Rseg
X125 15 26 Rseg
X126 16 27 Rseg
X127 17 28 Rseg
X128 18 29 Rseg
X129 19 30 Rseg
X130 20 31 Rseg
X131 21 32 Rseg
X132 22 33 Rseg
X133 23 34 Rseg
X134 24 35 Rseg
X135 25 36 Rseg
X136 26 37 Rseg
X137 27 38 Rseg
X138 28 39 Rseg
X139 29 40 Rseg
X140 30 41 Rseg
X141 31 42 Rseg
X142 32 43 Rseg
X143 33 44 Rseg
X144 34 45 Rseg
X145 35 46 Rseg
X146 36 47 Rseg
X147 37 48 Rseg
X148 38 49 Rseg
X149 39 50 Rseg
X150 40 51 Rseg
X151 41 52 Rseg
X152 42 53 Rseg
X153 43 54 Rseg
X154 44 55 Rseg
X155 45 56 Rseg
X156 46 57 Rseg
X157 47 58 Rseg
X158 48 59 Rseg
X159 49 60 Rseg
X160 50 61 Rseg
X161 51 62 Rseg
X162 52 63 Rseg
X163 53 64 Rseg
X164 54 65 Rseg
X165 55 66 Rseg
X166 56 67 Rseg
X167 57 68 Rseg
X168 58 69 Rseg
X169 59 70 Rseg
X170 60 71 Rseg
X171 61 72 Rseg
X172 62 73 Rseg
X173 63 74 Rseg
X174 64 75 Rseg
X175 65 76 Rseg
X176 66 77 Rseg
X177 67 78 Rseg
X178 68 79 Rseg
X179 69 80 Rseg
X180 70 81 Rseg
X181 71 82 Rseg
X182 72 83 Rseg
X183 73 84 Rseg
X184 74 85 Rseg
X185 75 86 Rseg
X186 76 87 Rseg
X187 77 88 Rseg
X188 78 89 Rseg
X189 79 90 Rseg
X190 80 91 Rseg
X191 81 92 Rseg
X192 82 93 Rseg
X193 83 94 Rseg
X194 84 95 Rseg
X195 85 96 Rseg
X196 86 97 Rseg
X197 87 98 Rseg
X198 88 99 Rseg
X199 89 100 Rseg
X200 90 101 Rseg
X201 91 102 Rseg
X202 92 103 Rseg
X203 93 104 Rseg
X204 94 105 Rseg
X205 95 106 Rseg
X206 96 107 Rseg
X207 97 108 Rseg
X208 98 109 Rseg
X209 99 110 Rseg
X210 100 111 Rseg
X211 101 112 Rseg
X212 102 113 Rseg
X213 103 114 Rseg
X214 104 115 Rseg
X215 105 116 Rseg
X216 106 117 Rseg
X217 107 118 Rseg
X218 108 119 Rseg
X219 109 120 Rseg
X220 110 121 Rseg
C1 13 gnd 2e-15
C2 14 gnd 2e-15
C3 15 gnd 2e-15
C4 16 gnd 2e-15
C5 17 gnd 2e-15
C6 18 gnd 2e-15
C7 19 gnd 2e-15
C8 20 gnd 2e-15
C9 21 gnd 2e-15
C10 24 gnd 2e-15
C11 25 gnd 2e-15
C12 26 gnd 2e-15
C13 27 gnd 2e-15
C14 28 gnd 2e-15
C15 29 gnd 2e-15
C16 30 gnd 2e-15
C17 31 gnd 2e-15
C18 32 gnd 2e-15
C19 35 gnd 2e-15
C20 36 gnd 2e-15
C21 37 gnd 2e-15
C22 38 gnd 2e-15
C23 39 gnd 2e-15
C24 40 gnd 2e-15
C25 41 gnd 2e-15
C26 42 gnd 2e-15
C27 43 gnd 2e-15
C28 46 gnd 2e-15
C29 47 gnd 2e-15
C30 48 gnd 2e-15
C31 49 gnd 2e-15
C32 50 gnd 2e-15
C33 51 gnd 2e-15
C34 52 gnd 2e-15
C35 53 gnd 2e-15
C36 54 gnd 2e-15
C37 57 gnd 2e-15
C38 58 gnd 2e-15
C39 59 gnd 2e-15
C40 60 gnd 2e-15
C41 61 gnd 2e-15
C42 62 gnd 2e-15
C43 63 gnd 2e-15
C44 64 gnd 2e-15
C45 65 gnd 2e-15
C46 68 gnd 2e-15
C47 69 gnd 2e-15
C48 70 gnd 2e-15
C49 71 gnd 2e-15
C50 72 gnd 2e-15
C51 73 gnd 2e-15
C52 74 gnd 2e-15
C53 75 gnd 2e-15
C54 76 gnd 2e-15
C55 79 gnd 2e-15
C56 80 gnd 2e-15
C57 81 gnd 2e-15
C58 82 gnd 2e-15
C59 83 gnd 2e-15
C60 84 gnd 2e-15
C61 85 gnd 2e-15
C62 86 gnd 2e-15
C63 87 gnd 2e-15
C64 90 gnd 2e-15
C65 91 gnd 2e-15
C66 92 gnd 2e-15
C67 93 gnd 2e-15
C68 94 gnd 2e-15
C69 95 gnd 2e-15
C70 96 gnd 2e-15
C71 97 gnd 2e-15
C72 98 gnd 2e-15
C73 101 gnd 2e-15
C74 102 gnd 2e-15
C75 103 gnd 2e-15
C76 104 gnd 2e-15
C77 105 gnd 2e-15
C78 106 gnd 2e-15
C79 107 gnd 2e-15
C80 108 gnd 2e-15
C81 109 gnd 2e-15
Vin 1 gnd 1.0
I1 121 999 PULSE(0uA 30uA 30ps 0 0 30ps 2n)
Vprobe 999 gnd DC 0.0
*I2 61 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
*I1 121 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
*I1 61 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
*I1 121 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
*I1 61 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
*I1 121 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
*I1 61 gnd PULSE(0uA 30uA 30ps 0 0 30ps 2n)
.end
